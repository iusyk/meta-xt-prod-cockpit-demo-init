SRC_URI = "git://github.com/xen-troops/${PN}.git"
SRCREV = "152eaf422b65eecc5bee63521e4606be21d2cb27"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1ebbd3e34237af26da5dc08a4e440464"
