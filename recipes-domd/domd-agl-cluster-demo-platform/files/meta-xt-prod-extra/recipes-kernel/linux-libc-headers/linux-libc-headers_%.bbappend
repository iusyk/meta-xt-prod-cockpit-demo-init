RENESAS_BSP_URL = "git://github.com/xen-troops/linux.git"

BRANCH = "master"
SRCREV = "79b42d9fbd28b13d882a8c60b7e89b497662ae96"
LINUX_VERSION = "4.14.75"
