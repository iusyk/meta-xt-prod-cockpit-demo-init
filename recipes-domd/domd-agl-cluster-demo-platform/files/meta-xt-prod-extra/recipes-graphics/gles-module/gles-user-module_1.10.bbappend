require inc/xt_shared_env.inc

BRANCH = "1.10/ED5187610_GCC-8"
SRCREV = "aa0ec2348087a3e449ea7c969af8cfd662feb52e"
