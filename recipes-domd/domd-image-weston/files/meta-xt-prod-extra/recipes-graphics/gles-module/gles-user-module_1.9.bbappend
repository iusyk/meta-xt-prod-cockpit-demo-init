require inc/xt_shared_env.inc

BRANCH = "1.9/4991288"
SRCREV = "3681f88bb4c341709d8c77024b953a24ffd97f05"

SRC_URI_remove = " \
    file://gcc6_pvr_um_1.9.patch \
"
