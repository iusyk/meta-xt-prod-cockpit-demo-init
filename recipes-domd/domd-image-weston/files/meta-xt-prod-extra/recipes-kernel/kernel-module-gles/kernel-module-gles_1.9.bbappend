require inc/xt_shared_env.inc

PVRKM_URL = "git://git@gitpct.epam.com/epmd-aepr/pvr_km_vgpu_img.git"
BRANCH = "1.9/4991288-4.9"
SRCREV = "e4b3662e16593786c93c09c6180739be9ee0994e"
