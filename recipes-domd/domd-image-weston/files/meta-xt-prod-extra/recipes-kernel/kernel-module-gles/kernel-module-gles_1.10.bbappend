require inc/xt_shared_env.inc

PVRKM_URL = "git://git@gitpct.epam.com/epmd-aepr/pvr_km_vgpu_img.git"
BRANCH = "1.10/ED5187610_GCC-8"
SRCREV = "2fadae71a582f928f57217dd76984685ef31bc1a"
